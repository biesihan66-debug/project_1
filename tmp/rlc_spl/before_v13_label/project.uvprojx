# Keil uVision project project.uvprojx, settings and files
target Full (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0xF800) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: RLC_V1_2_Full +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\startup;.\USER;.\Library;.\System
  memory RVCT4: ROM 0x8000000 size 0xf800
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\startup\stm32f103c8_flash.sct
  group USER - Entry
    ./USER/: main.c stm32f10x_conf.h
  group System - Application
    ./System/: App_RLC.c App_RLC.h Key.c Key.h OLED_Display.c OLED_Display.h Serial_Debug.c Serial_Debug.h Text_Format.c Text_Format.h
  group System - Measurement
    ./System/: RLC_Measure.c RLC_Measure.h RLC_Calculate.c RLC_Calculate.h RLC_Calibration.c RLC_Calibration.h RLC_Types.h
  group System - Hardware
    ./System/: BSP_Board.c BSP_Board.h BSP_PinMap.h DDS_Signal.c ADC_Sample.c Range_Switch.c OLED_I2C.c Flash_Calibration.c DDS_Signal.h ADC_Sample.h Range_Switch.h OLED_I2C.h Flash_Calibration.h BSP_Clock.c BSP_Clock.h BSP_GPIO.c BSP_GPIO.h BSP_USART.c BSP_USART.h OLED.c OLED.h OLED_Data.c OLED_Data.h delay.c delay.h
  group Startup
    ./startup/: startup_stm32f10x_md.s stm32f103c8_flash.sct stm32f10x.h core_cm3.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_i2c.c stm32f10x_i2c.h
target Basic (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: RLC_V1_2_Basic +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,RLC_APP_BASIC_ONLY=1
  c misc: --no-multibyte-chars
  c include: .\startup;.\USER;.\Library;.\System
  memory RVCT4: ROM 0x8000000 size 0xf800
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\startup\stm32f103c8_flash.sct
target Fixed1k (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: RLC_V1_2_Fixed1k +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,RLC_APP_FIXED_1KHZ=1
  c misc: --no-multibyte-chars
  c include: .\startup;.\USER;.\Library;.\System
  memory RVCT4: ROM 0x8000000 size 0xf800
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\startup\stm32f103c8_flash.sct
