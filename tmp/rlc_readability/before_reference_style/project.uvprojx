# Keil uVision project project.uvprojx, settings and files
target Full (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0xF800) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: RLC_V1_1_Full +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --no-multibyte-chars
  c include: .\System
  memory RVCT4: ROM 0x8000000 size 0xf800
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\startup\stm32f103c8_flash.sct
  group Startup
    ./startup/: startup_stm32f103c8.s stm32f103c8_flash.sct
  group Application
    ./USER/: main.c
    ./System/: oled_result_display.c oled_result_display.h measurement_debug_output.c measurement_debug_output.h measurement_text_format.h
  group Measurement
    ./System/: automatic_rlc_measurement.c automatic_rlc_measurement.h rlc_impedance_calculation.c rlc_impedance_calculation.h open_short_calibration.c open_short_calibration.h rlc_measurement_port.h rlc_measurement_types.h
  group STM32 Board
    ./System/: stm32_rlc_board.c stm32_rlc_board.h board_pin_map.h stm32f103_registers.h rlc_board_internal.h excitation_signal.c voltage_current_sampling.c feedback_range_switch.c oled_i2c_transport.c calibration_flash_storage.c
target Basic (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: RLC_V1_1_Basic +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RLC_APP_BASIC_ONLY=1
  c misc: --no-multibyte-chars
  c include: .\System
  memory RVCT4: ROM 0x8000000 size 0xf800
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\startup\stm32f103c8_flash.sct
target Fixed1k (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: RLC_V1_1_Fixed1k +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RLC_APP_FIXED_1KHZ=1
  c misc: --no-multibyte-chars
  c include: .\System
  memory RVCT4: ROM 0x8000000 size 0xf800
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\startup\stm32f103c8_flash.sct
