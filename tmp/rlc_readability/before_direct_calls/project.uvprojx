# Keil uVision project project.uvprojx, settings and files
target Full (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0xF800) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: RLC_V1_1_Full +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --no-multibyte-chars
  c include: .\System
  memory RVCT4: ROM 0x8000000 size 0xf800
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\startup\stm32f103c8_flash.sct
  group USER - Entry
    ./USER/: main.c
  group System - Application
    ./System/: App_RLC.c App_RLC.h Key.c Key.h OLED_Display.c OLED_Display.h Serial_Debug.c Serial_Debug.h Text_Format.c Text_Format.h
  group System - Measurement
    ./System/: RLC_Measure.c RLC_Measure.h RLC_Calculate.c RLC_Calculate.h RLC_Calibration.c RLC_Calibration.h RLC_Types.h RLC_Hardware.h
  group System - Hardware
    ./System/: BSP_Board.c BSP_Board.h BSP_PinMap.h BSP_Registers.h DDS_Signal.c ADC_Sample.c Range_Switch.c OLED_I2C.c Flash_Calibration.c DDS_Signal.h ADC_Sample.h Range_Switch.h OLED_I2C.h Flash_Calibration.h
  group Startup
    ./startup/: startup_stm32f103c8.s stm32f103c8_flash.sct
target Basic (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: RLC_V1_1_Basic +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RLC_APP_BASIC_ONLY=1
  c misc: --no-multibyte-chars
  c include: .\System
  memory RVCT4: ROM 0x8000000 size 0xf800
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\startup\stm32f103c8_flash.sct
target Fixed1k (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: RLC_V1_1_Fixed1k +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RLC_APP_FIXED_1KHZ=1
  c misc: --no-multibyte-chars
  c include: .\System
  memory RVCT4: ROM 0x8000000 size 0xf800
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\startup\stm32f103c8_flash.sct
