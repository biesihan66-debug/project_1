# Keil uVision project project.uvprojx, settings and files
target Full (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x24000000-0x2407FFFF) CLOCK(240000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: RLC_V1_4_Full +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32H743xx,USE_FULL_LL_DRIVER,USE_PWR_LDO_SUPPLY,DATA_IN_D2_SRAM,HSE_VALUE=25000000
  c misc: --no-multibyte-chars
  c include: .\USER;.\System;.\Library\CMSIS;.\Library\Device;.\Library\LL
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  scatter file: .\startup\stm32h743vi_flash.sct
  group USER - Entry
    ./USER/: main.c
  group System - Application
    ./System/: App_RLC.c App_RLC.h Key.c Key.h OLED_Display.c OLED_Display.h Serial_Debug.c Serial_Debug.h Text_Format.c Text_Format.h
  group System - Measurement
    ./System/: RLC_Measure.c RLC_Measure.h RLC_Calculate.c RLC_Calculate.h RLC_Calibration.c RLC_Calibration.h RLC_Types.h
  group System - Hardware
    ./System/: BSP_Board.c BSP_Board.h BSP_PinMap.h DDS_Signal.c ADC_Sample.c Range_Switch.c OLED_I2C.c Flash_Calibration.c DDS_Signal.h ADC_Sample.h Range_Switch.h OLED_I2C.h Flash_Calibration.h BSP_Clock.c BSP_Clock.h BSP_GPIO.c BSP_GPIO.h BSP_USART.c BSP_USART.h OLED.c OLED.h OLED_Data.c OLED_Data.h delay.c delay.h
  group STM32H743 Startup
    ./startup/: startup_stm32h743xx.s system_stm32h7xx.c
  group STM32H7 LL
    ./Library/LL/: stm32h7xx_ll_gpio.c
target Basic (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: as above
  output: RLC_V1_4_Basic +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32H743xx,USE_FULL_LL_DRIVER,USE_PWR_LDO_SUPPLY,DATA_IN_D2_SRAM,HSE_VALUE=25000000,RLC_APP_BASIC_ONLY=1
  c misc: --no-multibyte-chars
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  scatter file: .\startup\stm32h743vi_flash.sct
target Fixed1k (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: as above
  output: RLC_V1_4_Fixed1k +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32H743xx,USE_FULL_LL_DRIVER,USE_PWR_LDO_SUPPLY,DATA_IN_D2_SRAM,HSE_VALUE=25000000,RLC_APP_FIXED_1KHZ=1
  c misc: --no-multibyte-chars
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  scatter file: .\startup\stm32h743vi_flash.sct
